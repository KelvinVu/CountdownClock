# IAR project CountdownClock.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\MyLib\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: CountdownClock.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: Interrupt_VectorTable.c main.c ram.c ram.h
  group MyLib/inc
    ../../MyLib/inc/: Func.h FUNCTION_TT_nhannut.h gpio.h LCD.h stm8l_define.h timer_delay.h
  group MyLib/src
    ../../MyLib/src/: Func.c FUNCTION_TT_nhannut.c gpio.c LCD.c timer_delay.c
